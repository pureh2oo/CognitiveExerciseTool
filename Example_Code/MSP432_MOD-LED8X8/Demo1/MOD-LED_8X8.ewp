# IAR project MOD-LED_8X8.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2231 MSP430G2231
  General.GStackSize2: 50
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2231.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: font.c font.h main.c main.h matrix.c matrix.h
