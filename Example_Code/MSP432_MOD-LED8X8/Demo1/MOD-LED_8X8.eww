<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MOD-LED_8X8.ewp</path>
  </project>
  <batchBuild/>
</workspace>


